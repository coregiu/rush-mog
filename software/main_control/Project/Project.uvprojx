# Keil uVision project Project.uvprojx, settings and files
target Targets (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\APP;..\CORE;..\LIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group LIB
    ../LIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c
  group APP
    ../APP/: main.c led.c includes.h
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group FreeRTOS/Source
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Ports
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../FreeRTOS/portable/MemMang/: heap_4.c
